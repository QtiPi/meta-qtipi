require recipes-core/image/core-image-qtipi.bb

IMAGE_INSTALL += "network-config-wifi-ap"
