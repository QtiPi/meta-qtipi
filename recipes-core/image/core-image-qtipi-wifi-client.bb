# Image configured as a Wifi client

require recipes-core/image/core-image-qtipi.bb

IMAGE_INSTALL += "network-config-wifi-client"
