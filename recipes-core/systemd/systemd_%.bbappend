FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-systemd-Make-wait-online-return-when-any-interface-i.patch"

