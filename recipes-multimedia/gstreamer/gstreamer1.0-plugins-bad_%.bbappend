PACKAGECONFIG:remove = "vulkan gl"
